options:
  parameters:
    generate_options: qt_gui
    id: audiomix
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    alias: tx_audio
    comment: |-
      tx_audio
      Audio to Transceiver
    device_name: pipewire_tx_audio
    samp_rate: samp_rate
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    alias: rx_audio
    comment: |-
      rx_audio
      Audio from Transceiver to Monitor
    device_name: pipewire_rx_audio
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    alias: src_mic
    comment: |-
      src_mic

      Microphone Voice Signal
    device_name: pipewire_src_mic
    samp_rate: samp_rate
  states: {}
- name: audio_source_1
  id: audio_source
  parameters:
    alias: src_mon
    comment: |-
      src_mon

      Audio Out from Transceiver
    device_name: pipewire_src_mon
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    alias: wav_dump
    bits_per_sample1: FORMAT_PCM_16
    comment: |-
      wav_dump
      Dump all audio to WAV
    file: |
      "dump" + datetime.now().strftime("%Y_%m_%dT%H.%M") + ".wav"
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alias: Meter_Mic
    comment: Meter_Mic
    label1: MIC
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    alias: Meter_Mon
    color1: dark red
    comment: Meter_Mon
    label1: RX Audio
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [audio_source_0, '0', audio_sink_0, '0']
- [audio_source_0, '0', blocks_wavfile_sink_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']
- [audio_source_1, '0', audio_sink_1, '0']
- [audio_source_1, '0', blocks_wavfile_sink_0, '1']
- [audio_source_1, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
